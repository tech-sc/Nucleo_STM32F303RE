# IAR project Nucleo_STM32F303RE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xE ST STM32F303xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303xE; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\APL; ..\..\Boot; ..\..\OS; ..\..\OS\FreeRTOS\include; ..\..\OS\FreeRTOS\portable\ARM_CM3; ..\..\CubeF3Drivers; ..\..\CubeF3Drivers\CMSIS\Include; ..\..\CubeF3Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\CubeF3Drivers\STM32F3xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\OS; ..\..\OS\FreeRTOS\portable\ARM_CM3
  ILINK.IlinkOutputFile: Nucleoc_STM32F303RE.out
  ILINK.IlinkIcfFile: ..\..\CubeF3Drivers\stm32f303xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  group APL
    ../../APL/: APL_osRes.h
  group Boot
    ../../Boot/: main.c
  group CubeF3Drivers
    ../../CubeF3Drivers/: startup_stm32f303xe.s system_stm32f3xx.c
  group CubeF3Drivers/CMSIS/Device/Include
    ../../CubeF3Drivers/CMSIS/Device/ST/STM32F3xx/Include/: stm32f303xe.h stm32f3xx.h system_stm32f3xx.h
  group CubeF3Drivers/STM32F3xx_HAL_Driver/Src
    ../../CubeF3Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_cortex.c stm32f3xx_ll_rcc.c stm32f3xx_ll_utils.c
  group OS
    ../../OS/: FreeRTOSConfig.h hook.c os.h
  group OS/FreeRTOS
    ../../OS/FreeRTOS/: list.c queue.c tasks.c
  group OS/FreeRTOS/include
    ../../OS/FreeRTOS/include/: FreeRTOS.h list.h portable.h queue.h semphr.h task.h
  group OS/FreeRTOS/portable
    ../../OS/FreeRTOS/portable/MemMang/: heap_1.c
    ../../OS/FreeRTOS/portable/ARM_CM3/: port.c portasm.s portmacro.h
