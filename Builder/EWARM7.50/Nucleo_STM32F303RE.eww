<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Nucleo_STM32F303RE.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>DebugBuild</name>
      <member>
        <project>Nucleo_STM32F303RE</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


